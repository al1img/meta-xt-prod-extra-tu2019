require inc/agl-image.inc