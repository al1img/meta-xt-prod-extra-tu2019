RDEPENDS_${PN}_remove = " \
    cluster-connman-conf \
    ${AGL_APPS} \
"

RDEPENDS_${PN}_append = " \
    cluster-dashboard-vis \
"
